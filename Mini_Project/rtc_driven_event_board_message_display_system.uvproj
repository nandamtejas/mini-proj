# Keil uVision project rtc_driven_event_board_message_display_system.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2148 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: message_marquee_test2 +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s delay.c lcd.c message_marquee.c ADC.c cfgPortPin.c kpm.c kpm_admin.c lm35.c messages.c rtc.c
    ./tests/: message_marquee_test2.c
